# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c XPT2046.c XPT2046.h delay.h delay.c EKey.c EKey.h matrixled.c matrixled.h Timer0.c Timer0.h matrixkey.c matrixkey.h ds18b20.c ds18b20.h smg.c smg.h IR.c IR.h SG90.c SG90.h
